#define LEDS 6
#include "reg51.h"

unsigned char code Select[] = {0x01,0x02,0x04,0x08,0x10,0x20};

unsigned char code LED_CODES[] = {
  0xc0,0xf9,0xa4,0xb0,0x99,//0-4
  0x92,0x82,0xf8,0x80,0x90,//5-9
  0x88,0x83,0xc6,0xa1,0x86,//a,b,c,d,e
  0x8e,0xff,0x0c,0x89,0x7f,0xbf//f,space,p,h,.,-
};

void main()
{
	char i = 0;
	long int j;
	while(1)
	{
		P2 = 1;
		P1 = LED_CODES[i];
		P2 = Select[i];
		for(j = 3000; j > 0; j-- );
		i++;
		if(i > 5)
		{
			i = 0;
		}
	}
}